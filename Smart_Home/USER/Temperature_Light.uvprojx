# Keil uVision project Temperature_Light.uvprojx, settings and files
target Temperature_Light (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103V8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Temperature_Light +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAEDWARE\adc;..\HAEDWARE\key;..\HAEDWARE\led
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c STM32F10x.s
  group HARDWARE
    ../HAEDWARE/adc/: adc.c
    ../HAEDWARE/key/: key.c
    ../HAEDWARE/led/: led.c led.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
software components: CMSIS:CORE 5.4.0
